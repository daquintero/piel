* `ngspice` Sim Input for `OperatingPointTb`
* Generated by `vlsirtools.NgspiceNetlister`
*
* Anonymous `circuit.Package`
* Generated by `vlsirtools.NgspiceNetlister`
*

.SUBCKT Straight
+ e1 e2
* No parameters

rr1
+ e1 e2
+ 1000
* No parameters

.ENDS

.SUBCKT OperatingPointTb
+ VSS
* No parameters

vVDC
+ VDC_p VSS
+ dc '1'
+ ac '0'
* No parameters

xdut
+ VDC_p VSS
+ Straight
* No parameters

.ENDS

xtop 0 OperatingPointTb // Top-Level DUT

.op
