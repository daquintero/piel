* `ngspice` Sim Input for `Tb`
* Generated by `vlsirtools.NgspiceNetlister`
*
* Anonymous `circuit.Package`
* Generated by `vlsirtools.NgspiceNetlister`
*

.SUBCKT Tb
+ vss
* No parameters

vvdc
+ vout vss
+ pulse ('0m' '1000m' '1m' '1m' '1m' '10m' '10m')
* No parameters

rr
+ vout vss
+ 1000K
* No parameters

.ENDS

xtop 0 Tb // Top-Level DUT

.tran 0.001 0.1
